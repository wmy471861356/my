# Keil uVision project iSO-STM32.uvprojx, settings and files
target USART1（polling） (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\usart;..\..\User\length;..\..\User\tick;..\..\User\LED;..\..\User\sys;..\..\User\usart1;..\..\User\delay;..\..\User\LCD;..\..\User\tick;..\..\User\ADC;..\..\User\KEY;..\..\User\src;..\..\User\LSENS;..\..\User\WDG;..\..\User\TIMER;..\..\User\PWM;..\..\User\EXTI;..\..\User\DHT11
  asm include: ..\..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h beep.c
    ../../User/usart/: bsp_usart1.c
    ../../User/length/: bsp_length.c
    ../../User/tick/: bsp_tick.c
    ../../User/LED/: led.c
    ../../User/sys/: sys.c
    ../../User/delay/: delay.c
    ../../../ALIENTEK MINISTM32 实验3 串口实验/SYSTEM/usart/: usart.c
    ./: a.txt
    ../../User/LCD/: lcd.c
    ../../User/KEY/: key.c
    ../../User/DHT11/: dht11.c
  group DOC
    ../../Doc/: readme.txt
